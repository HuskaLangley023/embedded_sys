# Keil uVision project s523010910148.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::.\ARMCC v5.06 update4)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: s523010910148 +hex
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: PART_TM4C1294NCPDT
  c include: .\inc;.\driverlib;..\lab1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: main.c callback.c control_loop.c flash_led.c s800_i2c.c
  group Lib
    E:/Program Files/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
